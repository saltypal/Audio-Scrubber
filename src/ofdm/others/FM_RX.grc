options:
  parameters:
    author: Dusan Stokic
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: down_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: RF Gain
    min_len: '20'
    rangeType: int
    start: '10'
    step: '5'
    stop: '70'
    value: '15'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Station Select
    rangeType: int
    start: '87000000'
    step: '100000'
    stop: '108000000'
    value: '87000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    name: Sampling Bandpass
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: down_rate
    fc: tuner
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 3,0,1,2
    name: Demod Out
    type: float
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 900e6
    dev_args: driver=rtlsdr
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
