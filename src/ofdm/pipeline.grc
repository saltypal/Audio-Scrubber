options:
  parameters:
    author: satya
    generate_options: no_gui
    id: pipeline
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\ofdm\TxRx\Transcorn\inter.png
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Bunker\OneDrive - Amrita vishwa vidyapeetham\BaseCamp\AudioScrubber\src\ofdm\TxRx\Transcorn\testfile_img.png
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '96'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"QPSK"'
    minoutbuf: '65536'
    occupied_carriers: ((-4, -3, -2, -1, 1, 2, 3, 4),)
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21,),)
    pilot_symbols: ((1, 1, 1, -1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: 900M
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '9000000'
    dev_args: driver=rtlsdr
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_ofdm_tx_0_0, '0']
- [digital_ofdm_tx_0_0, '0', soapy_plutosdr_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
